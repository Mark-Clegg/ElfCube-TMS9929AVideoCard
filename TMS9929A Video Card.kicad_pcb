# Repository Mark-Clegg/ElfCube-TMS9929AVideoCard

File README.md:

# Elf-Cube - TMS 9929A Video Card
Simple retro computer based on the 1802 series of processors.

Provides a component video interface (YCrCb) using the Texas Instruments TMS9929A Video Display Processor

## KiCad design TMS9929A Video Card.kicad_pcb

Parts:
C1, C2: 27pF; C_Disc_D3.8mm_W2.6mm_P2.50mm
C3: 10uF; CP_Radial_D5.0mm_P2.50mm
C4, C5, C6, C7, C8, C9, C10: 100nF; C_Disc_D3.8mm_W2.6mm_P2.50mm
H1, H2: Mounting Hole; MountingHole_3.2mm_M3_Pad_Via
J1: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Horizontal
R1: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: 74LS32; DIP-14_W7.62mm
U2: 74LS04; DIP-14_W7.62mm
U3: TMS9929A; DIP-40_W15.24mm_Socket
U4, U5, U6: 74LS374; DIP-20_W7.62mm
U7: HM62256BLP; DIP-28_W15.24mm_Socket
Y1: 10.738635 MHz; Crystal_HC49-U_Horizontal

Connections:
/A0: U4.5 (O1), U7.10 (A0)
/A1: U4.6 (O2), U7.9 (A1)
/A2: U4.9 (O3), U7.8 (A2)
/A3: U4.12 (O4), U7.7 (A3)
/A4: U4.15 (O5), U7.6 (A4)
/A5: U4.16 (O6), U7.5 (A5)
/A6: U4.19 (O7), U7.4 (A6)
/A7: U5.5 (O1), U7.3 (A7)
/A8: U5.6 (O2), U7.25 (A8)
/A9: U5.9 (O3), U7.24 (A9)
/A10: U5.12 (O4), U7.21 (A10)
/A11: U5.15 (O5), U7.23 (A11)
/A12: U5.16 (O6), U7.2 (A12)
/A13: U5.19 (O7), U7.26 (A13)
/AD0: U3.10, U4.3 (D0), U5.3 (D0), U6.3 (D0)
/AD1: U3.9, U4.4 (D1), U5.4 (D1), U6.4 (D1)
/AD2: U3.8, U4.7 (D2), U5.7 (D2), U6.7 (D2)
/AD3: U3.7, U4.8 (D3), U5.8 (D3), U6.8 (D3)
/AD4: U3.6, U4.13 (D4), U5.13 (D4), U6.13 (D4)
/AD5: U3.5, U4.14 (D5), U5.14 (D5), U6.14 (D5)
/AD6: U3.4, U4.17 (D6), U5.17 (D6), U6.17 (D6)
/AD7: U3.3, U4.18 (D7), U5.18 (D7), U6.18 (D7)
/RD0: U3.32, U6.2 (O0), U7.11 (Q0)
/RD1: U3.31, U6.5 (O1), U7.12 (Q1)
/RD2: U3.30, U6.6 (O2), U7.13 (Q2)
/RD3: U3.29, U6.9 (O3), U7.15 (Q3)
/RD4: U3.28, U6.12 (O4), U7.16 (Q4)
/RD5: U3.27, U6.15 (O5), U7.17 (Q5)
/RD6: U3.26, U6.16 (O6), U7.18 (Q6)
/RD7: U3.25, U6.19 (O7), U7.19 (Q7)
B-Y: U3.35; also elsewhere on the board
COL: U2.6, U5.11 (Cp)
D0: J1.24, U3.17
D1: J1.23, U3.18
D2: J1.22, U3.19
D3: J1.21, U3.20
D4: J1.20, U3.21
D5: J1.19, U3.22
D6: J1.18, U3.23
D7: J1.17, U3.24
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, H2.1, J1.39, J1.40, U1.7 (GND), U2.7 (GND), U2.9, U3.12, U4.1 (OE), U4.10 (GND), U5.1 (OE), U5.10 (GND), U6.10 (GND), U7.1 (A14), U7.14 (GND); also elsewhere on the board
unnamed: C1.1, U3.40, Y1.2
unnamed: C2.1, U3.39, Y1.1
unnamed: R1.2, U1.1, U1.2, U1.4, U1.5
unnamed: U1.8, U3.14
unnamed: U1.11, U3.15
unnamed: U2.2, U2.3
unnamed: U2.4, U2.5
Q: J1.7, U3.13
R-Y: U3.38; also elsewhere on the board
ROW: U2.10, U4.11 (Cp)
R~W: U2.13, U3.11, U6.1 (OE), U7.27 (~WE)
VCC: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, J1.1, J1.2, R1.1, U1.14 (VCC), U2.14 (VCC), U3.33, U4.20 (VCC), U5.20 (VCC), U6.20 (VCC), U7.28 (VCC); also elsewhere on the board
Y: U3.36; also elsewhere on the board
~CAS: U2.1, U3.2, U7.20 (~CS)
~CLEAR: J1.5, U3.34
~IOR: J1.26, U1.12
~IOW: J1.25, U1.10
~N4: J1.30, U1.9, U1.13
~RAS: U2.11, U3.1
~R~W: U2.12, U6.11 (Cp), U7.22 (~OE)

Parts:
C11, C12, C13, C14, C15: 100nF; C_Disc_D3.8mm_W2.6mm_P2.50mm
C16: 10nF; C_Disc_D3.8mm_W2.6mm_P2.50mm
C17, C18, C19: 47uF; CP_Radial_D5.0mm_P2.50mm
J2: Conn_Coaxial_x3_Isolated; RCA Phono Socket
Q1, Q2, Q3: BC548; TO-92_Inline_Wide
R2, R3, R4: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 680K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6, R9, R11, R13: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7: 4K7; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R10, R12, R14: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R15, R16, R17: 220R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U8: 4066; DIP-14_W7.62mm
U9: LM1881; DIP-8_W7.62mm
U10: TL081; DIP-8_W7.62mm

Connections:
/Video Signal Processing/VREF: R7.1, R8.2, R10.2, R12.2, R14.2
B-Y: R4.1, U8.4, U8.11; also elsewhere on the board
GND: C11.2, C13.2, C14.2, C15.2, C16.2, J2.2, J2.4, J2.6, R2.2, R3.2, R4.2, R5.2, R15.2, R16.2, R17.2, U8.7 (VSS), U8.8, U9.4 (GND), U10.4 (V-); also elsewhere on the board
unnamed: C12.1, U9.2 (VIDEO)
unnamed: C13.1, R5.1, U9.6 (INT)
unnamed: C16.1, U8.10, U10.3 (+)
unnamed: C17.1, Q1.3 (E), R15.1
unnamed: C17.2, J2.1
unnamed: C18.1, Q2.3 (E), R16.1
unnamed: C18.2, J2.5
unnamed: C19.1, Q3.3 (E), R17.1
unnamed: C19.2, J2.3
unnamed: Q1.2 (B), R9.1, R10.1
unnamed: Q2.2 (B), R11.1, R12.1
unnamed: Q3.2 (B), R13.1, R14.1
unnamed: R6.2, U8.9, U8.12
unnamed: R7.2, U10.2 (-), U10.6
unnamed: R11.2, U8.2
unnamed: R13.2, U8.3
unnamed: U8.6, U9.1 (CSYNC)
unnamed: U8.5, U8.13, U9.5 (BURST)
R-Y: R3.1, U8.1; also elsewhere on the board
VCC: C11.1, C14.1, C15.1, Q1.1 (C), Q2.1 (C), Q3.1 (C), R6.1, R8.1, U8.14 (VDD), U9.8 (VCC), U10.7 (V+); also elsewhere on the board
Y: C12.2, R2.1, R9.2; also elsewhere on the board

Board: 2 copper layers, 100.0 x 100.0 mm, 54 parts (0 on the bottom side), 80 nets.

## Commit log

2021-11-06 Rev 1.0
2021-11-06 Added README.md
2021-11-08 Updated wiki
